Commit message: se2 cleanup

File: bumpybot/dummy_se2.urdf (robot description, URDF)
Before this commit: robot se2, 4 links, 3 joints
Links:
- link base: geometry collision cylinder length=0.5 radius=0.36; visual cylinder length=0.6 radius=0.36
